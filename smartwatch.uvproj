# Keil uVision project smartwatch.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: smartwatch +hex
  c flags: Optimize=8 SizeSpeed=1
  group header_file
    ./: STARTUP.A51
    ./header_file/: oled.h oledfont.h bmp.h
    ./delay_c/: delay.h
    ./clock_c/: clock.h
    ./key_c/: key.h
  group key_c
    ./key_c/: key.c
  group oled_c
    ./oled_c/: oled.c
  group main()
    ./: main.c
  group delay_c
    ./delay_c/: delay.c
  group clock_c
    ./clock_c/: clock.c
